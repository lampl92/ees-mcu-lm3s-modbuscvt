# Keil uVision project freeRTOS-lwip-lm3s8962.uvprojx, settings and files
target lwIP-1.32 freeRTOS-7.1.1 (ARM-ADS)
  device: LM3S8962 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos_lwip_lm3s8962
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: rvmdk PART_LM3S8962
  c include: ..\..\src\app;..\..\src\bsp;..\..\src\drv;..\..\src\net;..\..\src\os\freeRTOS_7.1.1\include;..\..\src\third_party\lwip-1.3.2;..\..\src\third_party\lwip-1.3.2\src\include;..\..\src\third_party\lwip-1.3.2\src\include\ipv4;..\..\src\third_party\lwip-1.3.2\ports\stellaris\include;..\..\src\third_party\lwip-1.3.2\ports\stellaris\netif
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --entry Reset_Handler
  group App
    ../../src/app/: main.c app_cfg.h includes.h Startup.s
  group Bsp
    ../../src/bsp/: bsp.c bsp_led.c rit128x96x4.c
  group Drv
    ../../src/drv/driverlib/: sysctl.c ssi.c uart.c ethernet.c gpio.c hibernate.c interrupt.c cpu.c timer.c
  group Utils
    ../../src/drv/utils/: locator.c uartstdio.c ustdlib.c cmdline.c
  group Net
    ../../src/net/: network.c ping.c
    ../../src/app/: lwipopts.h
    ../../src/third_party/lwip-1.3.2/src/include/lwip/: opt.h
  group lwIP
    ../../src/drv/utils/: lwiplib.c
    ../../src/third_party/lwip-1.3.2/ports/stellaris/: sys_arch.c perf.c
    ../../src/third_party/lwip-1.3.2/ports/stellaris/netif/: stellarisif.c
    ../../src/third_party/lwip-1.3.2/src/netif/: etharp.c ethernetif.c
  group lwIP-api
    ../../src/third_party/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP-core
    ../../src/third_party/lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwIP-IPv4
    ../../src/third_party/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group freeRTOS
    ../../src/os/freeRTOS_7.1.1/: heap_2.c list.c port.c queue.c tasks.c
    ../../src/os/freeRTOS_7.1.1/include/: FreeRTOSConfig.h
software components: CMSIS:CORE 5.5.0
