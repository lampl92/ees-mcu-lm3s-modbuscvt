# Keil uVision project freeRTOS-lwip1.4-lm3s.uvprojx, settings and files
target freeRTOS-lwip1.4 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LM3S8938 Texas Instruments
  pack: Keil.LM3S_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freeRTOS-lwip-lm3s
  c flags: Optim=3 uC99=1 v6Lang=3 v6LangP=3
  c define: rvmdk PART_LM3S8962
  c include: ..\..\src\app;..\..\src\bsp;..\..\src\drv;..\..\src\net;..\..\src\os\freeRTOS_7.1.0\include;..\..\src\third_party\lwip-2.1.2\src\include;..\..\src\third_party\lwip-2.1.2\src\include\ipv4;..\..\src\third_party\lwip-2.1.2\ports\stellaris\netif;..\..\src\third_party\lwip-2.1.2\ports\stellaris\include;..\..\src\lightmodbus;..\..\src\httpserver_raw
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../../src/app/: main.c app_cfg.h includes.h Startup.s FiFo.c cgifuncs.c lmi_fs.c
    ../../src/httpserver_raw/: httpd.c
  group userlib
    ../../src/app/: mb_cvt.c cmd.c cmd.h user_epprom.c user_epprom.h webserver.c webserver.h io.h
  group Bsp
    ../../src/bsp/: bsp.c
  group Drv
    ../../src/drv/driverlib/: cpu.c ethernet.c gpio.c interrupt.c hibernate.c sysctl.c ssi.c timer.c uart.c i2c.c watchdog.c
    ../../../host_lm3s8962/src/drv/driverlib/: flash.c
  group Utils
    ../../src/drv/utils/: lwiplib.c ustdlib.c uartstdio.c cmdline.c crc.c flash_pb.c
  group Net
    ../../src/net/: network.c
  group lwIP
    ../../src/third_party/lwip-1.4.0/ports/stellaris/: sys_arch.c perf.c
    ../../src/third_party/lwip-1.4.0/ports/stellaris/netif/: stellarisif.c
    ../../src/third_party/lwip-1.4.0/src/netif/: etharp.c ethernetif.c slipif.c
  group freeRTOS
    ../../src/os/freeRTOS_7.1.0/: heap_2.c list.c port.c queue.c tasks.c
    ../../src/os/freeRTOS_7.1.0/include/: FreeRTOSConfig.h
  group lightmodbus
    ../../src/lightmodbus/: base.h base.impl.h debug.h debug.impl.h lightmodbus.h master.h master.impl.h master_func.h master_func.impl.h modbus_cfg.h slave.h slave.impl.h slave_func.h slave_func.impl.h
  group lwip-api-2.1.2
    ../../src/third_party/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-core-2.1.2
    ../../src/third_party/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip-ipv4
    ../../src/third_party/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
software components: CMSIS:CORE 5.5.0, Compiler:I/O:STDERR 1.2.0
